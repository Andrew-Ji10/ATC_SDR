options:
  parameters:
    description: Pluto SDR receiver for FM broadcast and airband ATC
    generate_options: qt_gui
    id: atc_receiver
    output_language: python
    run_options: run
    title: ATC SDR Receiver
  states: {}

blocks:
- name: audio_on
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,3,1,1
    label: Audio on
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Band center (MHz)
    type: real
    value: '120.1'
  states: {}
- name: chan_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: demod
  id: variable
  parameters:
    comment: |-
      Active demodulator: 0 WFM, 1 AM, 2 NBFM.
      Auto: 87.5-108 MHz WFM, 108-137 MHz AM (airband), else NBFM.
    value: (0 if 87.5e6 <= freq < 108e6 else 1 if 108e6 <= freq <= 137e6 else 2) if mode == 0 else mode - 1
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Tuned frequency (Hz). Set by the entry box,
      or directly by double-clicking the spectrum / waterfall.
    value: freq_mhz * 1e6
  states: {}
- name: freq_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency (MHz)
    type: real
    value: '120.1'
  states: {}
- name: lo
  id: variable
  parameters:
    comment: |-
      SDR center frequency. Stays on the band center while the tuned
      frequency is inside the band (and clear of DC); otherwise follows it.
    value: band_mhz * 1e6 if 30e3 <= abs(freq - band_mhz * 1e6) <= samp_rate / 2 - 120e3 else freq - tune_offset
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Mode
    label0: Auto
    label1: WFM (broadcast)
    label2: AM (airband / ATC)
    label3: NBFM
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,2
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '73'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Band span / sample rate.
      Must be a multiple of chan_rate (240k).
    value: '2400000'
  states: {}
- name: squelch_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Squelch dB (AM/NBFM, -120 = off)
    start: '-120'
    step: '1'
    stop: '0'
    value: '-120'
  states: {}
- name: tune_offset
  id: variable
  parameters:
    comment: |-
      Where the tuned channel sits relative to the LO
      when the band has to follow it.
    value: '250000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Volume
    start: '0'
    step: '0.05'
    stop: '3'
    value: '1'
  states: {}
- name: am_agc
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    max_gain: 1e4
    reference: '1.0'
    type: complex
  states: {}
- name: am_chan
  id: fir_filter_xxx
  parameters:
    decim: int(chan_rate / audio_rate)
    taps: firdes.low_pass(1.0, chan_rate, 5e3, 2e3)
    type: ccc
  states: {}
- name: am_dc
  id: dc_blocker_xx
  parameters:
    length: '128'
    long_form: 'True'
    type: ff
  states: {}
- name: am_env
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: am_lpf
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1.0, audio_rate, 3.5e3, 1e3)
    type: fff
  states: {}
- name: am_squelch
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: squelch_db
    type: complex
  states: {}
- name: click_spec
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: click_wf
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: gate_am
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0 if demod == 1 else 0.0
    type: float
  states: {}
- name: gate_nbfm
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0 if demod == 2 else 0.0
    type: float
  states: {}
- name: gate_wfm
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0 if demod == 0 else 0.0
    type: float
  states: {}
- name: meter
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,4
    label1: '"Signal"'
    max: '0'
    min: '-120'
    name: '"Signal (tuned channel)"'
    type: float
    unit1: '"dB"'
  states: {}
- name: mix
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: nbfm
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: nbfm_chan
  id: fir_filter_xxx
  parameters:
    decim: int(chan_rate / audio_rate)
    taps: firdes.low_pass(1.0, chan_rate, 8e3, 2e3)
    type: ccc
  states: {}
- name: nbfm_squelch
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'False'
    ramp: '0'
    threshold: squelch_db
    type: complex
  states: {}
- name: pluto
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    comment: |-
      URI '' = auto-detect over USB.
      Or e.g. 'ip:192.168.2.1'.
    filter_source: '''Auto'''
    frequency: int(lo)
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ''''''
  states: {}
- name: sig_avg
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: sig_db
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: sig_decim
  id: blocks_keep_one_in_n
  parameters:
    n: int(audio_rate / 10)
    type: float
  states: {}
- name: sig_pwr
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: speaker
  id: audio_sink
  parameters:
    device_name: ''''''
    samp_rate: audio_rate
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: lo
    fftsize: '2048'
    grid: 'True'
    gui_hint: 3,0,1,4
    legend: 'False'
    name: '"Band (double-click to tune)"'
    showports: 'True'
    type: complex
    update_time: '0.05'
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: vol
  id: blocks_multiply_const_xx
  parameters:
    const: volume * audio_on
    type: float
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: lo
    fftsize: '2048'
    gui_hint: 4,0,1,4
    int_max: '-30'
    int_min: '-110'
    legend: 'False'
    showports: 'True'
    type: complex
    update_time: '0.05'
  states: {}
- name: wfm
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(chan_rate / audio_rate)
    quad_rate: chan_rate
  states: {}
- name: xlate
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq - lo
    decim: int(samp_rate / chan_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 100e3, 20e3)
    type: ccc
  states: {}

connections:
- [am_agc, '0', am_env, '0']
- [am_chan, '0', am_squelch, '0']
- [am_chan, '0', sig_pwr, '0']
- [am_dc, '0', am_lpf, '0']
- [am_env, '0', am_dc, '0']
- [am_lpf, '0', gate_am, '0']
- [am_squelch, '0', am_agc, '0']
- [gate_am, '0', mix, '1']
- [gate_nbfm, '0', mix, '2']
- [gate_wfm, '0', mix, '0']
- [mix, '0', vol, '0']
- [nbfm, '0', gate_nbfm, '0']
- [nbfm_chan, '0', nbfm_squelch, '0']
- [nbfm_squelch, '0', nbfm, '0']
- [pluto, '0', spectrum, '0']
- [pluto, '0', waterfall, '0']
- [pluto, '0', xlate, '0']
- [sig_avg, '0', sig_db, '0']
- [sig_db, '0', sig_decim, '0']
- [sig_decim, '0', meter, '0']
- [sig_pwr, '0', sig_avg, '0']
- [spectrum, freq, click_spec, inpair]
- [vol, '0', speaker, '0']
- [waterfall, freq, click_wf, inpair]
- [wfm, '0', gate_wfm, '0']
- [xlate, '0', am_chan, '0']
- [xlate, '0', nbfm_chan, '0']
- [xlate, '0', wfm, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
